#include <string.h>
#include "jpeg_util.h"

#define M_SOF0 0xC0
#define M_SOF2 0xC2
#define M_DHT  0xC4
#define M_SOI  0xD8
#define M_EOI  0xD9
#define M_SOS  0xDA

/* ITU-T T.81 Annex K.3 표준 허프만 테이블 (MJPEG 가 생략하는 그것) */
static const uint8_t std_dht[JPEG_STD_DHT_SIZE] = {
    0xFF, 0xC4, 0x01, 0xA2,
    /* 휘도 DC */
    0x00,
    0x00, 0x01, 0x05, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B,
    /* 색차 DC */
    0x01,
    0x00, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B,
    /* 휘도 AC */
    0x10,
    0x00, 0x02, 0x01, 0x03, 0x03, 0x02, 0x04, 0x03, 0x05, 0x05, 0x04, 0x04, 0x00, 0x00, 0x01, 0x7D,
    0x01, 0x02, 0x03, 0x00, 0x04, 0x11, 0x05, 0x12, 0x21, 0x31, 0x41, 0x06, 0x13, 0x51, 0x61, 0x07,
    0x22, 0x71, 0x14, 0x32, 0x81, 0x91, 0xA1, 0x08, 0x23, 0x42, 0xB1, 0xC1, 0x15, 0x52, 0xD1, 0xF0,
    0x24, 0x33, 0x62, 0x72, 0x82, 0x09, 0x0A, 0x16, 0x17, 0x18, 0x19, 0x1A, 0x25, 0x26, 0x27, 0x28,
    0x29, 0x2A, 0x34, 0x35, 0x36, 0x37, 0x38, 0x39, 0x3A, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49,
    0x4A, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59, 0x5A, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69,
    0x6A, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x7A, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89,
    0x8A, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 0x99, 0x9A, 0xA2, 0xA3, 0xA4, 0xA5, 0xA6, 0xA7,
    0xA8, 0xA9, 0xAA, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6, 0xB7, 0xB8, 0xB9, 0xBA, 0xC2, 0xC3, 0xC4, 0xC5,
    0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xD2, 0xD3, 0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDA, 0xE1, 0xE2,
    0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE8, 0xE9, 0xEA, 0xF1, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8,
    0xF9, 0xFA,
    /* 색차 AC */
    0x11,
    0x00, 0x02, 0x01, 0x02, 0x04, 0x04, 0x03, 0x04, 0x07, 0x05, 0x04, 0x04, 0x00, 0x01, 0x02, 0x77,
    0x00, 0x01, 0x02, 0x03, 0x11, 0x04, 0x05, 0x21, 0x31, 0x06, 0x12, 0x41, 0x51, 0x07, 0x61, 0x71,
    0x13, 0x22, 0x32, 0x81, 0x08, 0x14, 0x42, 0x91, 0xA1, 0xB1, 0xC1, 0x09, 0x23, 0x33, 0x52, 0xF0,
    0x15, 0x62, 0x72, 0xD1, 0x0A, 0x16, 0x24, 0x34, 0xE1, 0x25, 0xF1, 0x17, 0x18, 0x19, 0x1A, 0x26,
    0x27, 0x28, 0x29, 0x2A, 0x35, 0x36, 0x37, 0x38, 0x39, 0x3A, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48,
    0x49, 0x4A, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59, 0x5A, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68,
    0x69, 0x6A, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x7A, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87,
    0x88, 0x89, 0x8A, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 0x99, 0x9A, 0xA2, 0xA3, 0xA4, 0xA5,
    0xA6, 0xA7, 0xA8, 0xA9, 0xAA, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6, 0xB7, 0xB8, 0xB9, 0xBA, 0xC2, 0xC3,
    0xC4, 0xC5, 0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xD2, 0xD3, 0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDA,
    0xE2, 0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE8, 0xE9, 0xEA, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8,
    0xF9, 0xFA,
};

/* SOS 마커 위치를 찾으면서 헤더 정보를 채운다. 실패 시 -1 */
static long scan_to_sos(const uint8_t *d, size_t len, jpeg_header_t *hdr)
{
    if (len < 4 || d[0] != 0xFF || d[1] != M_SOI) {
        return -1;
    }
    memset(hdr, 0, sizeof(*hdr));
    size_t pos = 2;
    while (pos + 4 <= len) {
        if (d[pos] != 0xFF) {
            return -1;
        }
        uint8_t marker = d[pos + 1];
        if (marker == 0xFF) {
            /* 채움 바이트 */
            pos++;
            continue;
        }
        if (marker == M_SOS) {
            return (long)pos;
        }
        if (marker == M_EOI) {
            return -1;
        }
        size_t seg_len = ((size_t)d[pos + 2] << 8) | d[pos + 3];
        if (seg_len < 2 || pos + 2 + seg_len > len) {
            return -1;
        }
        const uint8_t *seg = d + pos + 4;
        if (marker == M_DHT) {
            hdr->has_dht = true;
        } else if ((marker == M_SOF0 || marker == M_SOF2 || marker == 0xC1) && seg_len >= 11) {
            hdr->height = (uint16_t)((seg[1] << 8) | seg[2]);
            hdr->width = (uint16_t)((seg[3] << 8) | seg[4]);
            hdr->components = seg[5];
            /* 첫 번째 성분이 Y. seg[6]=id, seg[7]=샘플링(H<<4|V) */
            hdr->y_h_samp = seg[7] >> 4;
            hdr->y_v_samp = seg[7] & 0x0F;
        }
        pos += 2 + seg_len;
    }
    return -1;
}

int jpeg_parse_header(const uint8_t *data, size_t len, jpeg_header_t *out)
{
    if (data == NULL || out == NULL) {
        return -1;
    }
    if (scan_to_sos(data, len, out) < 0 || out->width == 0 || out->height == 0) {
        return -1;
    }
    return 0;
}

size_t jpeg_insert_std_dht(const uint8_t *in, size_t len, uint8_t *out, size_t out_cap)
{
    if (in == NULL || out == NULL) {
        return 0;
    }
    jpeg_header_t hdr;
    long sos = scan_to_sos(in, len, &hdr);
    if (sos < 0) {
        return 0;
    }
    if (hdr.has_dht) {
        if (out_cap < len) {
            return 0;
        }
        memcpy(out, in, len);
        return len;
    }
    if (out_cap < len + sizeof(std_dht)) {
        return 0;
    }
    memcpy(out, in, (size_t)sos);
    memcpy(out + sos, std_dht, sizeof(std_dht));
    memcpy(out + sos + sizeof(std_dht), in + sos, len - (size_t)sos);
    return len + sizeof(std_dht);
}
